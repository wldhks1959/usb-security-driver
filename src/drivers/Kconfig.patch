## src/drivers/usb_security/Kconfig
```kconfig
config USB_SECURITY_DRIVER
	tristate "Custom USB Security Keyring Driver"
	depends on USB
	default n
```
